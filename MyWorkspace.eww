<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab1\Lab1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab2\Lab2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3.1\Lab3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3\Lab3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab51\Lab3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3.1\Lab3 (2).ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab4\Lab32.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab51\Lab32.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab44\Lab34.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab 6\Lab34.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3b\Lab34.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab35\Lab35.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3b\Lab3b.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab44\Lab3v3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab3b\Lab3v3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab4\Lab4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab42\Lab42.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab43\Lab43.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab44\Lab44.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab 5\Lab5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab52\Lab52.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab58\Lab58.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab 6\Lab6.ewp</path>
    </project>
    <batchBuild />
</workspace>
